options:
  parameters:
    author: Johannes Demel
    category: '[Polar]'
    generate_options: hb
    id: hier_polar_decoder
    output_language: python
    title: Polar Decoder
  states: {}

blocks:
- name: polar_info_bytes
  id: variable
  parameters:
    value: info_size // 8
  states: {}
- name: var_decoder
  id: variable_polarwrap_decoderwrap
  parameters:
    block_size: frame_size
    decoder_impl: mixed
    dim1: '1'
    dim2: '4'
    error_detection_type: '16'
    frozen_bit_positions: frozen_bit_positions
    list_size: list_size
    ndim: '0'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: polar_info_bytes
    type: byte
  states: {}
- name: fec_generic_decoder_0
  id: fec_generic_decoder
  parameters:
    alias: POLARdecoder
    decoder: var_decoder
    itype: float
    otype: byte
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame size (bits)
    type: intx
    value: '936'
  states: {}
- name: frozen_bit_positions
  id: parameter
  parameters:
    label: Frozen Bit positions
    value: np.arange(768, dtype=int)
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: info_size
  id: parameter
  parameters:
    label: Info size (bits)
    type: intx
    value: 256 - 8
  states: {}
- name: interleaver_indices
  id: parameter
  parameters:
    label: Interleaver indices
    value: np.arange(936, dtype=int)
  states: {}
- name: length_tag_key
  id: parameter
  parameters:
    label: Length Tag Key
    type: str
    value: '"rx_len"'
  states: {}
- name: list_size
  id: parameter
  parameters:
    label: List size
    type: intx
    value: '4'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: symbolmapping_interleaver_0
  id: symbolmapping_interleaver
  parameters:
    interleaver_indices: interleaver_indices
    interleaver_mode: deinterleave
    is_packed: '1'
    type: float
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', pad_sink_0, '0']
- [fec_generic_decoder_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [pad_source_0, '0', symbolmapping_interleaver_0, '0']
- [symbolmapping_interleaver_0, '0', fec_generic_decoder_0, '0']

metadata:
  file_format: 1
