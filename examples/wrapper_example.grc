options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: polarwrapper_example
    output_language: python
    title: Wrapper Example
  states: {}

blocks:
- name: bits_per_frame
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: bytes_per_frame
  id: variable
  parameters:
    value: int(bits_per_frame // 8)
  states: {}
- name: crc_size
  id: variable
  parameters:
    value: '8'
  states: {}
- name: frozen_bit_positions
  id: variable
  parameters:
    value: pypolar.frozen_bits(polar_block_size, polar_info_size, 0.0)
  states: {}
- name: gfdm_constellation
  id: variable_constellation
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    precision: '8'
    type: qpsk
  states: {}
- name: polar_block_size
  id: variable
  parameters:
    value: 8 * 8 * (bytes_per_frame // 8)
  states: {}
- name: polar_info_bytes
  id: variable
  parameters:
    value: polar_info_size // 8
  states: {}
- name: polar_info_size
  id: variable
  parameters:
    value: polar_block_size // 4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.125e6 * 2 / 1000.
  states: {}
- name: var_decoder
  id: variable_polarwrap_decoderwrap
  parameters:
    block_size: polar_block_size - 88
    decoder_impl: mixed
    dim1: '1'
    dim2: '4'
    error_detection_type: crc_size
    frozen_bit_positions: frozen_bit_positions
    list_size: '8'
    ndim: '0'
  states: {}
- name: var_encoder
  id: variable_polarwrap_encoderwrap
  parameters:
    block_size: polar_block_size - 88
    dim1: '1'
    dim2: '4'
    error_detection_type: crc_size
    frozen_bit_positions: frozen_bit_positions
    ndim: '0'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1.'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_2
  id: blocks_char_to_float
  parameters:
    scale: '-.5'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: polar_info_bytes - crc_size // 8
    n: polar_info_bytes
    offset: '0'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-.9'
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: gfdm_constellation.bits_per_symbol()
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: gfdm_constellation.points()
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: gfdm_constellation
  states: {}
- name: fec_generic_decoder_0
  id: fec_generic_decoder
  parameters:
    decoder: var_decoder
    itype: float
    otype: byte
  states: {}
- name: fec_generic_encoder_0
  id: fec_generic_encoder
  parameters:
    encoder: var_encoder
    itype: byte
    otype: byte
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_pypolar
  id: import
  parameters:
    imports: import pypolar
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: '"LLRs"'
    nconnections: '2'
    size: '512'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    label2: ''
    name: '"bits"'
    nconnections: '2'
    size: bytes_per_frame * 4
    srate: samp_rate
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: packet_len
    type: float
    update_time: '0.1'
    ylabel: value
    ymax: '160'
    ymin: '-160'
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_1, '1']
- [blocks_char_to_float_2, '0', blocks_add_const_vxx_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_char_to_float_1, '0']
- [blocks_multiply_const_vxx_0, '0', fec_generic_decoder_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_float_2, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle_0, '0', blocks_char_to_float_0, '0']
- [blocks_throttle_0, '0', fec_generic_encoder_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [fec_generic_decoder_0, '0', blocks_keep_m_in_n_0, '0']
- [fec_generic_encoder_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [fec_generic_encoder_0, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
