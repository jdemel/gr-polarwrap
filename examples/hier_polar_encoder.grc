options:
  parameters:
    author: Johannes Demel
    category: '[Polar]'
    comment: |-
      Perform Encoding and Interleaving

      Be careful! This block assumes that some MAC already inserted a CRC.
      The decoder will rely on it!
    description: Perform Encoding and Interleaving
    generate_options: hb
    id: hier_polar_encoder
    output_language: python
    title: Polar Encoder
  states: {}

blocks:
- name: var_encoder
  id: variable_polarwrap_encoderwrap
  parameters:
    block_size: frame_size
    dim1: '1'
    dim2: '4'
    error_detection_type: '0'
    frozen_bit_positions: frozen_bit_positions
    ndim: '0'
  states: {}
- name: fec_generic_encoder_0
  id: fec_generic_encoder
  parameters:
    encoder: var_encoder
    itype: byte
    otype: byte
  states: {}
- name: fec_tagged_encoder_0
  id: fec_tagged_encoder
  parameters:
    encoder: var_encoder
    lentagname: length_tag_key
    maxoutbuf: frame_size // 8
    minoutbuf: frame_size // 8
    mtu: '1500'
  states: {state: disabled}
- name: frame_size
  id: parameter
  parameters:
    label: Frame size (bits)
    type: intx
    value: '936'
  states: {}
- name: frozen_bit_positions
  id: parameter
  parameters:
    label: Frozen Bit positions
    value: np.arange(256, dtype=int)
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interleaver_indices
  id: parameter
  parameters:
    label: Interleaver indices
    value: np.arange(936, dtype=int)
  states: {}
- name: length_tag_key
  id: parameter
  parameters:
    label: Length Tag Key
    type: str
    value: '"packet_len"'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: symbolmapping_interleaver_0
  id: symbolmapping_interleaver
  parameters:
    interleaver_indices: interleaver_indices
    interleaver_mode: interleave
    is_packed: '1'
    type: byte
  states: {}

connections:
- [fec_generic_encoder_0, '0', symbolmapping_interleaver_0, '0']
- [fec_tagged_encoder_0, '0', symbolmapping_interleaver_0, '0']
- [pad_source_0, '0', fec_generic_encoder_0, '0']
- [pad_source_0, '0', fec_tagged_encoder_0, '0']
- [symbolmapping_interleaver_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
